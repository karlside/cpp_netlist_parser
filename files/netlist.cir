simulator lang=spectre 
Cin (1 2 3)
